# IAR project Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C4 ST STM32F103C4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: E:\GitHub\workspace\STM32F1\Blink\Inc; E:\GitHub\workspace\STM32F1\Blink\Src; E:\GitHub\workspace\STM32F1\Drivers\STM32F1xx_HAL_Driver\Inc; E:\GitHub\workspace\STM32F1\Drivers\STM32F1xx_HAL_Driver\Src; E:\GitHub\workspace\STM32F1\Drivers\CMSIS\Device\ST\STM32F1xx\Include; E:\GitHub\workspace\STM32F1\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Test.hex
  ILINK.IlinkOutputFile: Test.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    Src/: main.c
  group Libraries
    Src/: startup_stm32f103xb.s
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group User
    Src/: delay.c init.c onewire.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c
