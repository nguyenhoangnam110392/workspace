# IAR project Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103x6; HAL_SPI_MODULE_ENABLED; HAL_SD_MODULE_ENABLED
  ICCARM.CCIncludePath2: I:\STM32F1\Projects\Project\Blink\Inc; I:\STM32F1\Projects\Project\Blink\Src; I:\STM32F1\Drivers\STM32F1xx_HAL_Driver\Inc; I:\STM32F1\Drivers\STM32F1xx_HAL_Driver\Src; I:\STM32F1\Drivers\CMSIS\Device\ST\STM32F1xx\Include; I:\STM32F1\Drivers\CMSIS\Include; I:\STM32F1\Projects\Project\Blink\FATFS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Test.bin
  ILINK.IlinkOutputFile: Test.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    Src/: main.c
  group FATFS
    FATFS/option/: ccsbcs.c
    FATFS/: diskio.c fattime.c ff.c
  group Libraries
    ../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_sd.c stm32f1xx_hal_spi.c
  group User
    Src/: init.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c
