# IAR project Backup of RF_Relay.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\STM8\Project\RF_Relay\User; D:\STM8\Project\RF_Relay\Libraries\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: RF_Relay.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    User/: main.c
  group Lib
    Libraries/src/: stm8s_adc1.c stm8s_clk.c stm8s_gpio.c stm8s_tim1.c stm8s_tim4.c
  group User
    User/: led.c stm8s_it.c
