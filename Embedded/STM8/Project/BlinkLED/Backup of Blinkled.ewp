# IAR project Backup of Blinkled.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: D:\STM8\Project\BlinkLED\User; D:\STM8\Project\BlinkLED\Libraries\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Blinkled.hex
  ILINK.IlinkOutputFile: Blinkled.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Libraries
    Libraries/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim4.c
  group User
    User/: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
