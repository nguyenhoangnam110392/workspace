# IAR project DHT11.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\workspace\Embedded\STM8\Project\DHT11\Src; D:\workspace\Embedded\STM8\Project\DHT11\Inc; D:\workspace\Embedded\STM8\STM8S_StdPeriph_Lib\Libraries\STM8S_StdPeriph_Driver\inc; D:\workspace\Embedded\STM8\STM8S_StdPeriph_Lib\Libraries\STM8S_StdPeriph_Driver\src; D:\workspace\Embedded\STM8\lib
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    Src/: main.c
  group Driver
    ../../STM8S_StdPeriph_Lib/Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim2.c
  group Libs
    Src/: delay.c DHT11.c init.c onewire.c
